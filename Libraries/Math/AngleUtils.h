#ifndef GARAGE_ANGLE_UTILS_H
#define GARAGE_ANGLE_UTILS_H

namespace garage
{

/***********************************************************************
** 函 数 名： wrapDeg(float deg)
** 函数说明： 把角度误差回绕到 -180~180
**---------------------------------------------------------------------
** 输入参数： deg，任意角度差
** 返回参数： 最短路径的角度差
***********************************************************************/
inline float wrapDeg(float deg)
{
    while (deg > 180.0f)
    {
        deg -= 360.0f;
    }
    while (deg < -180.0f)
    {
        deg += 360.0f;
    }
    return deg;
}

/***********************************************************************
** 函 数 名： normalize360(float deg)
** 函数说明： 把角度归一化到 0~360
**---------------------------------------------------------------------
** 输入参数： deg，任意角度
** 返回参数： 0~360 的角度
***********************************************************************/
inline float normalize360(float deg)
{
    while (deg >= 360.0f)
    {
        deg -= 360.0f;
    }
    while (deg < 0.0f)
    {
        deg += 360.0f;
    }
    return deg;
}

}

#endif
